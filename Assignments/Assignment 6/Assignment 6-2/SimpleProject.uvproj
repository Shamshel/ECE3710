# Keil uVision project SimpleProject.uvproj, settings and files
target SimpleProject (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: SimpleProject
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s main.c GPIO.c regop.c SYSCTL.c GPIO.h regop.h SYSCTL.h UART.c
